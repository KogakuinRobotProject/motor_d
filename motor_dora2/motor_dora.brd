# Repository KogakuinRobotProject/motor_d

File README.md:

# 直流モータドライバ基盤
## 仕様　<br>
to252のFETに対応している。用件によって必要となる定格のFETを使うこと<br>
PWMfreqは20kHz～50kHz(100kHzとかでも動くだろうけど、スイッチング損失えぐい)<br>

|FaultFlag|LEDstate|
|---|---|
|FF1|Green|
|FF2|Red|

<br>

|FF1state|FF2state|MDstate|
|---|---|---|
|0|0|Normal Operation|
|1|0|Overtemperature|
|0|1|Short-to-ground,Short-to-supply,Shorted load|
|1|1|V5 undervoltage,VREG undervoltage,Bootstrap undervoltage|

## FET使用例（FETゲート回路周りの定数）

|MOSFETname|Gate Register|Gate to Source Capasita|
|----|----|----|
|IPD034N06N3G|10|220~1000pF|
|DMTH4005SK3Q|10|1000~2200pF|

## 注意
FETを変えた場合ゲート入力抵抗、GS間容量(C_add)を適切な値に変更すること。目安は下記 <br>
 <br>
上式で容量を決めたらオシロスコープでFETの立ち下がりを見てセルフターンオンしないゲート入力抵抗を入れる <br>
基板上のC_5,C_6の値をFETの追加容量含んだトータルゲートチャージの10倍ほどのコンデンサに変更する<br>
※データシート上では容量ではなく、充電される電荷が記載されているため、電荷にV_gsを徐算すること<br>
※セルフターンオンしているとDtimeでカバーできない上下アームオン状態が生まれ、短絡しFETの発熱およびドライバの短絡検知、電流制限に引っかかる。<br>
※セルフターンオンであると思っていたものがそうでなかった。低負荷状態ではセルフターンオンの発生は確認できなかったが、高負荷時に発生する可能性があるため上記目安を参考に容量を追加すること。<br>

## EAGLE design motor_dora2/motor_dora.brd

Parts:
C1, C2, C5, C6, C7: 0.1u; C2012
C3: 0.47u; C2012
C4: 2.2uF_15V(min); C2012
C8, C9, C10, C11: C-EUC2012; C2012
R5: 33k; R2012
R6, R7, R8: 470; R2012
R12: 2k; R2012
R16, R17, R18, R19: 10; R2012
R20, R21, R22, R23: 10k; R2012
R_I1: 1k; 0603X4RESISTOR
U$1: A3921
U$2: TLP2105
U$3: TLP291
U$4: RGB_LED
U$5, U$6: 10k; 1005X4RESISTOR
U$7, U$12, U$15, U$19: SBR10M100P5Q; POWERDI_5
U$8, U$9, U$10, U$11: IPD034N06N3G; TO252
U$13: DF1B_L_4P
U$14: VL_4P
U$16: 1014CAPA
U$17: SMD_DAIOD
U$18: SSOT6_FET

Connections:
GHA: R16.1, U$1.PIN10 (PIN10_GHA)
GHB: R19.1, U$1.PIN5 (PIN5_GHB)
GLA: R17.1, U$1.PIN12 (PIN12_GLA)
GLB: R18.1, U$1.PIN3 (PIN3_GLB)
GND: C1.2, C2.2, C4.2, C7.2, C10.2, C11.2, R12.2, R22.1, R23.1, R_I1.3, U$1.PAD, U$1.PIN2 (PIN2_LSS), U$1.PIN17 (PIN17_GND), U$2.PIN5 (PIN5_GND), U$3.PIN3 (PIN3_TR_E), U$5.5, U$5.6, U$6.8, U$7.1 (A1), U$7.2 (A2), U$10.PIN3 (PIN3_S), U$11.PIN3 (PIN3_S), U$12.1 (A1), U$12.2 (A2), U$14.P$4 (PIN4), U$16.-, U$18.2 (PIN2_S2), U$18.5 (PIN5_S1)
GNDI: U$2.PIN2 (PIN2_KSODE1), U$2.PIN3 (PIN3_KSODE2), U$3.PIN2 (PIN2_KSODE), U$13.PIN1
L_H/L: R7.1, U$13.PIN3
L_RESET: R8.1, U$13.PIN2
unnamed: C2.1, U$1.PIN13 (PIN13_VBB), U$17.K
unnamed: R6.1, U$13.PIN4
unnamed: R6.2, U$2.PIN1 (PIN1_ANODE1)
unnamed: C3.1, U$1.PIN15 (PIN15_CP2)
unnamed: U$1.PIN27 (PIN27_RDEAD), U$6.4
unnamed: R7.2, U$2.PIN4 (PIN4_ANODE2)
unnamed: R5.2, U$1.PIN24 (PIN24_RESET), U$3.PIN4 (PIN4_TR_C)
unnamed: U$1.PIN23 (PIN23_PWMH), U$2.PIN6 (PIN6_VO2), U$5.2
unnamed: U$1.PIN26 (PIN26_FF2), U$6.1, U$18.1 (PIN1_G1)
unnamed: R8.2, U$3.PIN1 (PIN1_ANODE)
unnamed: C3.2, U$1.PIN16 (PIN16_CP1)
unnamed: U$1.PIN25 (PIN25_FF1), U$6.2, U$18.3 (PIN3_G2)
unnamed: C4.1, U$1.PIN8 (PIN8_VREG)
unnamed: R_I1.7, U$4.G_K
unnamed: R12.1, U$1.PIN28 (PIN28_VDSTH), U$6.3
unnamed: C6.2, U$1.PIN6 (PIN6_CB)
unnamed: C5.2, U$1.PIN9 (PIN9_CA)
unnamed: R_I1.2, U$18.4 (PIN4_D2)
unnamed: R_I1.8, U$4.R_K
unnamed: R_I1.6, U$4.B_K
unnamed: R_I1.1, U$18.6 (PIN6_D1)
unnamed: C8.1, R16.2, R20.2, U$8.PIN1 (PIN1_G)
unnamed: C9.1, R19.2, R21.2, U$9.PIN1 (PIN1_G)
unnamed: C11.1, R17.2, R23.2, U$10.PIN1 (PIN1_G)
unnamed: C10.1, R18.2, R22.2, U$11.PIN1 (PIN1_G)
unnamed: U$1.PIN19 (PIN19_PHASE), U$2.PIN7 (PIN7_VO1), U$5.1
PWML: U$1.PIN22 (PIN22_PWML), U$5.3
SA: C5.1, C8.2, R20.1, U$1.PIN11 (PIN11_SA), U$7.3 (K), U$8.PIN3 (PIN3_S), U$10.PIN2 (PIN2_D), U$14.P$3 (PIN3), U$19.1 (A1), U$19.2 (A2)
SB: C6.1, C9.2, R21.1, U$1.PIN4 (PIN4_SB), U$9.PIN3 (PIN3_S), U$11.PIN2 (PIN2_D), U$12.3 (K), U$14.P$2 (PIN2), U$15.1 (A1), U$15.2 (A2)
SR: U$1.PIN21 (PIN21_SR), U$5.4
V5: C1.1, C7.1, U$1.PIN20 (PIN20_V5), U$2.PIN8 (PIN8_VCC), U$4.B_A, U$4.G_A, U$4.R_A, U$5.7, U$5.8, U$6.5, U$6.6, U$6.7
VCC: R5.1, U$1.PIN1 (PIN1_VDRAIN), U$8.PIN2 (PIN2_D), U$9.PIN2 (PIN2_D), U$14.P$1 (PIN1), U$15.3 (K), U$16.+, U$17.A, U$19.3 (K)

Notes on the sheet:
vccとvdrainは同じ
330ufつけて

Board: 2 copper layers, 57.6 x 39.6 mm, 44 parts (18 on the bottom side), 40 nets.

## Commit log

2020-09-23 改良型モタドラ
    部品点数の低下、基板サイズの低下が行われた。
2020-09-24 ゲート駆動を調整
2020-11-09 pwm入力をプルダウンにした
